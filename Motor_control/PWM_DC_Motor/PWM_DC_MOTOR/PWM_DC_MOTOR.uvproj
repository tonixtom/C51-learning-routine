# Keil uVision project PWM_DC_MOTOR.uvproj, settings and files
target PWM_adjust (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: PWM_DC_MOTOR +hex
  c flags: Optimize=8 SizeSpeed=1
  group code
    ./: PWM.c
