# Keil uVision project 步进马达.uvproj, settings and files
target Target 1 (MCS-51)
  device: M6032 Acer Labs
  cpu: IRAM(0-0xFF) CLOCK(33000000) XRAM (0-0xFF) MODDP2
  output: 步进马达 +hex
  c flags: Optimize=8 SizeSpeed=1
  group code
    ./: 步进马达.c
