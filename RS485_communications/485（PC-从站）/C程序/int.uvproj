# Keil uVision project int.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: int +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51
  group Source Group 1
    ./: 232.c
