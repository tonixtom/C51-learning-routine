# Keil uVision project INTO+LED_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: M6759 Acer Labs
  cpu: IRAM(0-0xFF) CLOCK(40000000) XRAM (0-0xFF) MODDP2
  output: INTO+LED_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group code
    ./: LED_1.c
